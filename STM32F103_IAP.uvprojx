# Keil uVision project STM32F103_IAP.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: YT32B1_STM32F103_demo +hex
  c flags: Optim=2 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\CMSIS;.\Lib\inc;.\Lib\src;.\User;.\Startup;.\Hardware\LED;.\Hardware\KEY;.\Hardware\BUZZER;.\Basic\usart;.\User\Key;.\User\led;.\User\qma;.\User\uart;.\User\timer;.\User\adc;.\User\iwdg;.\User\sleep;.\User\IAP;.\User\STMFLASH;.\User\delay;.\User\sys;.\User\usart;.\User\inc;.\User\EVAL
  memory RVCT4: ROM 0x8000000 size 0x2fff
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ./CMSIS/: core_cm3.c system_stm32f10x.c
  group Lib
    ./Lib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_flash.c stm32f10x_i2c.c stm32f10x_exti.c stm32f10x_tim.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_iwdg.c
  group Startup
    ./Startup/: startup_stm32f10x_md.s
  group User
    ./User/src/: common.c download.c main.c upload.c ymodem.c stm32f10x_it.c key.c
software components: CMSIS:CORE 4.3.0
